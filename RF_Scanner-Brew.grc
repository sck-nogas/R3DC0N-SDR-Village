options:
  parameters:
    author: Scott C. Kennedy
    generate_options: qt_gui
    id: R3DC0N_RF_Scanner
    output_language: python
    title: RF Scanner
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: Frequency
    outputmsgname: value
    showports: 'False'
    start: '42000000'
    step: '100000'
    stop: '1002000000'
    value: '89500000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    outputmsgname: value
    showports: 'False'
    start: '230000'
    step: '10000'
    stop: '300000'
    value: '240000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    plotconst: 'False'
    plotfreq: 'False'
    plottime: 'False'
    rate: '1'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: frequency
    dev_args: rtl=0
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
