options:
  parameters:
    author: Scott C. Kenendy
    description: Simple FM Receiver
    generate_options: qt_gui
    id: FMReceive
    output_language: python
    title: R3DC0N FM Radio Receiver
  states: {}

blocks:
- name: Tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    orient: Qt.Horizontal
    start: '88100000'
    step: '100000'
    stop: '107900000'
    value: '105300000'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '1'
    widget: dial
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '40000'
    fc: Tuning
    fftsize: '1024'
    rate: '1'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    freq0: Tuning
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
