options:
  parameters:
    author: Scott C. Kenendy
    description: Simple FM Receiver
    generate_options: qt_gui
    id: FMReceive
    output_language: python
    title: R3DC0N FM Radio Receiver
  states: {}

blocks:
- name: Tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency
    outputmsgname: value
    showports: 'False'
    start: '88100000'
    step: '100000'
    stop: '107900000'
    value: '105300000'
  states: {}
- name: audio_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '1'
    widget: dial
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '40000'
    fc: Tuning
    fftsize: '1024'
    rate: '1'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: Tuning
    dev_args: rtl=0
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
